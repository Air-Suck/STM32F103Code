# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F401RE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE
  c include: ..\USER;..\CORE;..\HALLIB\Inc
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group CORE
    ../CORE/: cmsis_armcc.h cmsis_compiler.h cmsis_version.h core_cm4.h mpu_armv7.h startup_stm32f401xe.s
  group INC
    ./: main.h stm32f4xx.h stm32f4xx_hal_conf.h stm32f4xx_it.h stm32f401xe.h system_stm32f4xx.h
  group HALLIB
    ../HALLIB/Src/: stm32f4xx_hal_gpio.c stm32f4xx_hal_dma.c stm32f4xx_hal.c stm32f4xx_hal_rcc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_uart.c
    ../HALLIB/Inc/: stm32f4xx_hal_gpio.h stm32f4xx_hal.h stm32f4xx_hal_rcc.h stm32f4xx_hal_cortex.h stm32f4xx_hal_dma.h stm32f4xx_hal_uart.h
  group SYSTEM
    ./: Sys_Init.s
  group HARDWARE
    ./: MyI2C.c MyI2C.h Serial.c Serial.h
  group USER
    ./: system_stm32f4xx.c main.c
